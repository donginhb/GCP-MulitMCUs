# IAR project GCP-LPC43XX.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CORE_M4; LPC43XX; CN_APP
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../; ../../HwPlatform/LPC43XX/; ../../HwPlatform/LPC43XX/Core; ../../HwPlatform/LPC43XX/FirmwareLibrary; ../../HwPlatform/LPC43XX/HwDrivers; ../../HwPlatform/LPC43XX/Startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GCP-LPC43XX.bin
  ILINK.IlinkOutputFile: GCP-LPC43XX.out
  ILINK.IlinkIcfFile: settings\GCP-LPC43XX.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Algorithm/CRC
    ../../Algorithm/CRC/: CRC.h CRC16.c CRC8.c
  group Algorithm/Json
    ../../Algorithm/Json/: cJSON.c cJSON.h
  group Algorithm/RingBuff
    ../../Algorithm/RingBuff/: RingBuff.c RingBuff.h
  group Application
    ../../Application/: Application.h
  group Application/CNMachine
    ../../Application/CNMachine/: CN4357_IOTable.c CN4357_IOTable.h CN_HardwareDef.h CN_HwCtrl.c CN_HwCtrl.h CN_MainProc.c CN_MainProc.h
  group CMU
    ../../CMU/: CMU_DataStructDef.h CMU_ErrorCodeDef.h CMU_Interface.h CMU_PubFun.c UIN_GlobalDataDef.h
  group CMU/AbstractionLayer
    ../../CMU/AbstractionLayer/: AbstractionLayer.c AbstractionLayer.h CMU_CanInterface.c CMU_CanInterface.h CMU_EnetInterface.c CMU_EnetInterface.h CMU_UartInterface.c CMU_UartInterface.h CMU_Unpack.c CMU_Unpack.h
  group CMU/ProtocolLayer
    ../../CMU/ProtocolLayer/: CMU_CmdProcess.c CMU_CmdProcess.h CMU_ErrorMana.c CMU_ErrorMana.h CMU_ExApi.c CMU_ExApi.h CMU_PeriodDataMana.c CMU_PeriodDataMana.h CMU_RcvDataProcess.c CMU_RcvDataProcess.h CMU_SendDataProcess.c CMU_SendDataProcess.h ComDataStructDef.h
  group CNC/AHB
    ../../CNC/AHB/: AHB_DataStructDef.h AHB_Init.c AHB_Init.h
  group CNC/CNCSYS
    ../../CNC/CNCSYS/: CNCSYS_Config.h CNCSYS_Init.c CNCSYS_Interface.h CNCSYS_StateMan.c
  group CNC/CSM
    ../../CNC/CSM/: CSM_AutoCtrl.c CSM_AutoCtrl.h CSM_AxisMotion.c CSM_AxisMotion.h CSM_AxisStateMan.c CSM_AxisStateMan.h CSM_CircleDataProcess.c CSM_CircleDataProcess.h CSM_CrdSysState.c CSM_CrdSysState.h CSM_DataStructDef.h CSM_Interface.c CSM_Interface.h CSM_MainCtrl.c CSM_MainCtrl.h CSM_ParmMan.c CSM_ParmMan.h CSM_ProgBuf.c CSM_ProgBuf.h CSM_UserBuf.c CSM_UserBuf.h CSM_UserProgData.c CSM_UserProgData.h CSM_Version.c
  group CNC/DataStructDef
    ../../CNC/DataStructDef/: AXIS_DataStructDef.h CRD_DataStructDef.h DataType.h DEV_DataStructDef.h ERR_DataStructDef.h IO_DataStructDef.h IPO_DataStructDefPub.h IPR_DataStructDef.h MST_DataStructDef.h STCH_DataStructDef.h Sv_DataStructDef.h SYS_ConfigDef.h SYS_DataStructDef.h
  group CNC/DVM
    ../../CNC/DVM/: DEV_Abstract.c DEV_Abstract.h DEV_COM_CmdDef.h DEV_DriveStructDef.h DEV_Interface.h
  group CNC/DVM/BRD_Device
    ../../CNC/DVM/BRD_Device/: BRD_AxisDev.c BRD_AxisDev.h BRD_DEV_Driver.c BRD_DEV_Driver.h BRD_DEV_Interface.h
  group CNC/ErrorCodeDef
    ../../CNC/ErrorCodeDef/: CSM_ErrorCodeDef.h DVM_ErrorCodeDef.h IPO_ErrorCodeDef.h IPR_ErrorCodeDef.h SPM_ErrorCodeDef.h SYS_ErrorCodeDef.h UIN_ErrorCodeDef.h
  group CNC/ErrorCodeMan
    ../../CNC/ErrorCodeMan/: ECM_DataStructDef.h ECM_ErrorCodeMan.c ECM_ErrorCodeMan.h
  group CNC/IPO
    ../../CNC/IPO/: IPO-LIB-43XX.a IPO_DataStructDefPte.h IPO_Interface.h
  group CNC/MemoryAddr
    ../../CNC/MemoryAddr/: CNC_AddrDef.h SDRAM_AddrDef.c SDRAM_AddrDef.h UREG_DataMan.c UREG_DataMan.h UREG_Interface.h
  group CNC/MST
    ../../CNC/MST/: MST_DataStructDefPte.h MST_Interface.c MST_Interface.h MST_MainCtrl.c MST_MainCtrl.h MST_MCode.c MST_MCode.h MST_TCode.c MST_TCode.h
  group CNC/SPM
    ../../CNC/SPM/: SPM_ParmCheck.c SPM_ParmCheck.h SPM_SysCtrlParm.c SPM_SysCtrlParm.h
  group DataType
    ../../DataType/: DataType.h
  group ExtPeripheral/Ammeter
    ../../ExtPeripheral/Ammeter/: Ammeter_Spm91.c Ammeter_Spm91.h
  group ExtPeripheral/Eeprom
    ../../ExtPeripheral/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group ExtPeripheral/LCD
    ../../ExtPeripheral/LCD/: LCD1602.c LCD1602.h
  group ExtPeripheral/NixieTube
    ../../ExtPeripheral/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group ExtPeripheral/TempSensor
    ../../ExtPeripheral/TempSensor/: Ds18b20.c Ds18b20.h TempSensor.c TempSensor.h
  group HAL
    ../../HAL/: Demo.c Demo.h HAL_ADC.c HAL_ADC.h HAL_Can.c HAL_Can.h HAL_Config.h HAL_Delay.c HAL_Delay.h HAL_Exti.c HAL_Exti.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Pwm.c HAL_Pwm.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysTick.c HAL_SysTick.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h
  group HwPlatform/LPC43XX/Core
    ../../HwPlatform/LPC43XX/Core/: cmsis.h cmsis_43xx.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h sys_config.h
  group HwPlatform/LPC43XX/FirmwareLibrary
    ../../HwPlatform/LPC43XX/FirmwareLibrary/: adc_18xx_43xx.c adc_18xx_43xx.h aes_18xx_43xx.c aes_18xx_43xx.h arm_common_tables.h arm_math.h atimer_18xx_43xx.c atimer_18xx_43xx.h ccan_18xx_43xx.c ccan_18xx_43xx.h cguccu_18xx_43xx.h chip.h chip_18xx_43xx.c chip_clocks.h chip_lpc43xx.h clock_18xx_43xx.c clock_18xx_43xx.h creg_18xx_43xx.h dac_18xx_43xx.c dac_18xx_43xx.h eeprom_18xx_43xx.c eeprom_18xx_43xx.h emc_18xx_43xx.c emc_18xx_43xx.h enet_18xx_43xx.c enet_18xx_43xx.h error.h evrt_18xx_43xx.c evrt_18xx_43xx.h fmc_18xx_43xx.h fpu_init.c fpu_init.h gima_18xx_43xx.h gpdma_18xx_43xx.c gpdma_18xx_43xx.h gpio_18xx_43xx.c gpio_18xx_43xx.h gpiogroup_18xx_43xx.c gpiogroup_18xx_43xx.h hsadc_18xx_43xx.c hsadc_18xx_43xx.h i2c_18xx_43xx.c i2c_18xx_43xx.h i2c_common_18xx_43xx.h i2cm_18xx_43xx.c i2cm_18xx_43xx.h i2s_18xx_43xx.c i2s_18xx_43xx.h iap_18xx_43xx.c iap_18xx_43xx.h lcd_18xx_43xx.c lcd_18xx_43xx.h lpc_types.h mcpwm_18xx_43xx.h otp_18xx_43xx.c otp_18xx_43xx.h packing.h pinint_18xx_43xx.c pinint_18xx_43xx.h pmc_18xx_43xx.c pmc_18xx_43xx.h qei_18xx_43xx.h rgu_18xx_43xx.h ring_buffer.c ring_buffer.h ritimer_18xx_43xx.c ritimer_18xx_43xx.h romapi_18xx_43xx.h rtc_18xx_43xx.c rtc_18xx_43xx.h rtc_ut.c rtc_ut.h sct_18xx_43xx.c sct_18xx_43xx.h sct_pwm_18xx_43xx.c sct_pwm_18xx_43xx.h scu_18xx_43xx.h sdif_18xx_43xx.c sdif_18xx_43xx.h sdio_18xx_43xx.c sdio_18xx_43xx.h sdmmc.h sdmmc_18xx_43xx.c sdmmc_18xx_43xx.h sgpio_18xx_43xx.h spi_18xx_43xx.c spi_18xx_43xx.h spifi_18xx_43xx.h ssp_18xx_43xx.c ssp_18xx_43xx.h stopwatch.h stopwatch_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c timer_18xx_43xx.h uart_18xx_43xx.c uart_18xx_43xx.h usbhs_18xx_43xx.h wwdt_18xx_43xx.c wwdt_18xx_43xx.h
  group HwPlatform/LPC43XX/HwDrivers
    ../../HwPlatform/LPC43XX/HwDrivers/: HW_Adc.c HW_Adc.h HW_Eeprom.c HW_Eeprom.h HW_Exti.c HW_Exti.h HW_Flash.c HW_Flash.h HW_Gpio.c HW_Gpio.h HW_IRQHandler.c HW_IRQHandler.h HW_Mcpwm.c HW_Mcpwm.h HW_Rit.c HW_Rit.h HW_SysCtrl.c HW_SysCtrl.h HW_SysTick.c HW_SysTick.h HW_TimeInput.c HW_TimeInput.h HW_TimeOutput.c HW_TimeOutput.h HW_Uart.c HW_Uart.h HW_Watchdog.c HW_Watchdog.h
  group HwPlatform/LPC43XX/Startup
    ../../HwPlatform/LPC43XX/Startup/: iar_startup_lpc18xx43xx.s sysinit.c
  group Main
    ../../Main/: Main.c
  group SysCtrl
    ../../SysCtrl/: SYS_CmuConfig.c SYS_CmuConfig.h SYS_CncConfig.c SYS_CncConfig.h SYS_Config.h SYS_Ctrl.c SYS_Ctrl.h SYS_Init.c SYS_Init.h SYS_MemoryDef.h SYS_ParmMan.c SYS_ParmMan.h SysConfig.h
  group SysCtrl/SysUpdate
    ../../SysCtrl/SysUpdate/: Bootloader.c Bootloader.h SysUpdate.c SysUpdate.h
  group SysPeripheral/ADC
    ../../SysPeripheral/ADC/: ADC.c ADC.h
  group SysPeripheral/CAN
    ../../SysPeripheral/CAN/: Can.c Can.h CanBuff.c CanBuff.h CanDataStructDef.h
  group SysPeripheral/CoreCtrl
    ../../SysPeripheral/CoreCtrl/: CoreCtrl.c CoreCtrl.h
  group SysPeripheral/EXTI
    ../../SysPeripheral/EXTI/: EXTI.c EXTI.h
  group SysPeripheral/FLASH
    ../../SysPeripheral/FLASH/: Flash.c Flash.h
  group SysPeripheral/GPIO
    ../../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/I2C
    ../../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/PWM
    ../../SysPeripheral/PWM/: PWM.c PWM.h
  group SysPeripheral/SysTimer
    ../../SysPeripheral/SysTimer/: SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../../SysPeripheral/UART/: ModBus.c ModBus.h UART.c UART.h
  group SysPeripheral/WWDT
    ../../SysPeripheral/WWDT/: Watchdog.c Watchdog.h
  group Version
    ../../Version/: GCPVersion.h Version.h
