# IAR project GCP-LPC17XX.ewp, settings and files
configuration LPC1752-APP (ARM)
  General.OGChipSelectEditMenu: LPC1752 NXP LPC1752
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CORE_M3; LPC17XX
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../; ../../HwPlatform/LPC17XX/; ../../HwPlatform/LPC17XX/Core; ../../HwPlatform/LPC17XX/FirmwareLibrary; ../../HwPlatform/LPC17XX/HwDrivers; ../../HwPlatform/LPC17XX/Startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GCP-LPC17XX.bin
  ILINK.IlinkOutputFile: GCP-LPC17XX.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\LPC1752.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration LPC1768-APP (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ILINK.IlinkIcfFile: settings\GCP-LPC1768-APP.icf
  group Algorithm/CRC
    ../../Algorithm/CRC/: CRC.h CRC16.c CRC8.c
  group Algorithm/Json
    ../../Algorithm/Json/: cJSON.c cJSON.h
  group Algorithm/List
    ../../Algorithm/List/: List.h
  group Algorithm/RingBuff
    ../../Algorithm/RingBuff/: RingBuff.c RingBuff.h
  group Application
    ../../Application/: SLCVersion.h
  group Application/GCPTest
    ../../Application/GCPTest/: DS_IODef.c DS_IODef.h GCP_HardwareDef.h GCP_HwCtrl.c GCP_HwCtrl.h GCP_MainProc.c GCP_MainProc.h GCP_StateMan.c GCP_StateMan.h VD_MachineIO.c VD_MachineIO.h
  group CMU
    ../../CMU/: CMU_DataStructDef.h CMU_ErrorCodeDef.h CMU_Interface.h CMU_PubFun.c UIN_GlobalDataDef.h
  group CMU/AbstractionLayer
    ../../CMU/AbstractionLayer/: AbstractionLayer.c AbstractionLayer.h CMU_CanInterface.c CMU_CanInterface.h CMU_EnetInterface.c CMU_EnetInterface.h CMU_UartInterface.c CMU_UartInterface.h CMU_Unpack.c CMU_Unpack.h
  group CMU/ProtocolLayer
    ../../CMU/ProtocolLayer/: CMU_CmdProcess.c CMU_CmdProcess.h CMU_ErrorMana.c CMU_ErrorMana.h CMU_ExApi.c CMU_ExApi.h CMU_PeriodDataMana.c CMU_PeriodDataMana.h CMU_RcvDataProcess.c CMU_RcvDataProcess.h CMU_SendDataProcess.c CMU_SendDataProcess.h ComDataStructDef.h
  group CNC/AHB
    ../../CNC/AHB/: AHB_DataStructDef.h AHB_Init.c AHB_Init.h
  group CNC/CNCSYS
    ../../CNC/CNCSYS/: CNCSYS_Config.h CNCSYS_Init.c CNCSYS_Interface.h CNCSYS_StateMan.c
  group CNC/CSM
    ../../CNC/CSM/: CSM_AutoCtrl.c CSM_AutoCtrl.h CSM_AxisMotion.c CSM_AxisMotion.h CSM_AxisStateMan.c CSM_AxisStateMan.h CSM_CircleDataProcess.c CSM_CircleDataProcess.h CSM_CrdSysState.c CSM_CrdSysState.h CSM_DataStructDef.h CSM_Interface.c CSM_Interface.h CSM_MainCtrl.c CSM_MainCtrl.h CSM_ParmMan.c CSM_ParmMan.h CSM_ProgBuf.c CSM_ProgBuf.h CSM_UserBuf.c CSM_UserBuf.h CSM_UserProgData.c CSM_UserProgData.h CSM_Version.c
  group CNC/DataStructDef
    ../../CNC/DataStructDef/: AXIS_DataStructDef.h CRD_DataStructDef.h DataType.h DEV_DataStructDef.h ERR_DataStructDef.h IO_DataStructDef.h IPO_DataStructDefPub.h IPR_DataStructDef.h MST_DataStructDef.h STCH_DataStructDef.h Sv_DataStructDef.h SYS_ConfigDef.h SYS_DataStructDef.h
  group CNC/DVM
    ../../CNC/DVM/: DEV_Abstract.c DEV_Abstract.h DEV_COM_CmdDef.h DEV_DriveStructDef.h DEV_Interface.h
  group CNC/DVM/BRD_Device
    ../../CNC/DVM/BRD_Device/: BRD_AxisDev.c BRD_AxisDev.h BRD_DEV_Driver.c BRD_DEV_Driver.h BRD_DEV_Interface.h
  group CNC/ErrorCodeDef
    ../../CNC/ErrorCodeDef/: CSM_ErrorCodeDef.h DVM_ErrorCodeDef.h IPO_ErrorCodeDef.h IPR_ErrorCodeDef.h SPM_ErrorCodeDef.h SYS_ErrorCodeDef.h UIN_ErrorCodeDef.h
  group CNC/ErrorCodeMan
    ../../CNC/ErrorCodeMan/: ECM_DataStructDef.h ECM_ErrorCodeMan.c ECM_ErrorCodeMan.h
  group CNC/IPO
    ../../CNC/IPO/: IPO-LIB-17XX.a IPO_DataStructDefPte.h IPO_Interface.h
  group CNC/MemoryAddr
    ../../CNC/MemoryAddr/: CNC_AddrDef.h SDRAM_AddrDef.c SDRAM_AddrDef.h
  group CNC/MST
    ../../CNC/MST/: MST_DataStructDefPte.h MST_Interface.c MST_Interface.h MST_MainCtrl.c MST_MainCtrl.h MST_MCode.c MST_MCode.h MST_TCode.c MST_TCode.h
  group CNC/SPM
    ../../CNC/SPM/: SPM_ParmCheck.c SPM_ParmCheck.h SPM_SysCtrlParm.c SPM_SysCtrlParm.h
  group DataType
    ../../DataType/: DataType.h
  group ExtPeripheral/Ammeter
    ../../ExtPeripheral/Ammeter/: Ammeter_Spm91.c Ammeter_Spm91.h
  group ExtPeripheral/Eeprom
    ../../ExtPeripheral/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group ExtPeripheral/LCD
    ../../ExtPeripheral/LCD/: LCD1602.c LCD1602.h
  group ExtPeripheral/NixieTube
    ../../ExtPeripheral/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group ExtPeripheral/TempSensor
    ../../ExtPeripheral/TempSensor/: Ds18b20.c Ds18b20.h TempSensor.c TempSensor.h
  group HAL
    ../../HAL/: Demo.c Demo.h HAL_ADC.c HAL_ADC.h HAL_Can.c HAL_Can.h HAL_Config.h HAL_Delay.c HAL_Delay.h HAL_Exti.c HAL_Exti.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Pwm.c HAL_Pwm.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysTick.c HAL_SysTick.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h
  group HwPlatform/LPC17XX/Core
    ../../HwPlatform/LPC17XX/Core/: cmsis_175x_6x.h core_cm3.h error.h hw_types.h lpc_types.h sys_config.h
  group HwPlatform/LPC17XX/FirmwareLibrary
    ../../HwPlatform/LPC17XX/FirmwareLibrary/: adc_17xx_40xx.c adc_17xx_40xx.h can_17xx_40xx.c can_17xx_40xx.h chip.h chip_17xx_40xx.c chip_lpc175x_6x.h chip_lpc177x_8x.h clock_17xx_40xx.c clock_17xx_40xx.h cmp_17xx_40xx.c cmp_17xx_40xx.h cmsis.h crc_17xx_40xx.c crc_17xx_40xx.h dac_17xx_40xx.c dac_17xx_40xx.h eeprom_17xx_40xx.c eeprom_17xx_40xx.h emc_17xx_40xx.c emc_17xx_40xx.h enet_17xx_40xx.c enet_17xx_40xx.h fmc_17xx_40xx.h fpu_init.c fpu_init.h gpdma_17xx_40xx.c gpdma_17xx_40xx.h gpio_17xx_40xx.c gpio_17xx_40xx.h gpioint_17xx_40xx.c gpioint_17xx_40xx.h i2c_17xx_40xx.c i2c_17xx_40xx.h i2s_17xx_40xx.c i2s_17xx_40xx.h iap.c iap.h iocon_17xx_40xx.c iocon_17xx_40xx.h lcd_17xx_40xx.c lcd_17xx_40xx.h mcpwm_17xx_40xx.h pmu_17xx_40xx.c pmu_17xx_40xx.h pwm_17xx_40xx.c pwm_17xx_40xx.h qei_17xx_40xx.h ring_buffer.c ring_buffer.h ritimer_17xx_40xx.c ritimer_17xx_40xx.h romapi_17xx_40xx.h rtc_17xx_40xx.c rtc_17xx_40xx.h sdc_17xx_40xx.c sdc_17xx_40xx.h sdmmc_17xx_40xx.c sdmmc_17xx_40xx.h spi_17xx_40xx.c spi_17xx_40xx.h spifi_17xx_40xx.h ssp_17xx_40xx.c ssp_17xx_40xx.h sysctl_17xx_40xx.c sysctl_17xx_40xx.h sysinit_17xx_40xx.c timer_17xx_40xx.c timer_17xx_40xx.h uart_17xx_40xx.c uart_17xx_40xx.h usb_17xx_40xx.h wwdt_17xx_40xx.c wwdt_17xx_40xx.h
  group HwPlatform/LPC17XX/HwDrivers
    ../../HwPlatform/LPC17XX/HwDrivers/: HW_Adc.c HW_Adc.h HW_Can.c HW_Can.h HW_Exti.c HW_Exti.h HW_Flash.c HW_Flash.h HW_Gpio.c HW_Gpio.h HW_IRQHandler.c HW_IRQHandler.h HW_Mcpwm.c HW_Mcpwm.h HW_Pwm.c HW_Pwm.h HW_SysCtrl.c HW_SysCtrl.h HW_SysTick.c HW_SysTick.h HW_Tim.c HW_Tim.h HW_TimeDelay.c HW_TimeDelay.h HW_Uart.c HW_Uart.h HW_Watchdog.c HW_Watchdog.h
  group HwPlatform/LPC17XX/Startup
    ../../HwPlatform/LPC17XX/Startup/: iar_startup_LPC17xx.s sysinit.c
  group Main
    ../../Main/: Main.c
  group MotorCtrl
    ../../MotorCtrl/: MotorCtrl.c MotorCtrl.h
  group SysCtrl
    ../../SysCtrl/: SYS_CmuConfig.c SYS_CmuConfig.h SYS_CncConfig.c SYS_CncConfig.h SYS_Ctrl.c SYS_Ctrl.h SYS_Init.c SYS_Init.h SYS_MemoryDef.h SYS_ParmMan.c SYS_ParmMan.h SysConfig.h
  group SysCtrl/SysUpdate
    ../../SysCtrl/SysUpdate/: Bootloader.c Bootloader.h SysUpdate.c SysUpdate.h
  group SysPeripheral/ADC
    ../../SysPeripheral/ADC/: ADC.c ADC.h
  group SysPeripheral/CAN
    ../../SysPeripheral/CAN/: Can.c Can.h CanBuff.c CanBuff.h CanDataStructDef.h
  group SysPeripheral/CoreCtrl
    ../../SysPeripheral/CoreCtrl/: CoreCtrl.c CoreCtrl.h
  group SysPeripheral/EXTI
    ../../SysPeripheral/EXTI/: EXTI.c EXTI.h
  group SysPeripheral/FLASH
    ../../SysPeripheral/FLASH/: Flash.c Flash.h
  group SysPeripheral/GPIO
    ../../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/I2C
    ../../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/PWM
    ../../SysPeripheral/PWM/: PWM.c PWM.h PWM_Count.c PWM_Count.h PWM_MotorCtrl.c PWM_MotorCtrl.h
  group SysPeripheral/SysTimer
    ../../SysPeripheral/SysTimer/: SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../../SysPeripheral/UART/: ModBus.c ModBus.h UART.c UART.h
  group SysPeripheral/WWDT
    ../../SysPeripheral/WWDT/: Watchdog.c Watchdog.h
  group Version
    ../../Version/: GCPVersion.h Version.h
