# IAR project GCP-STM32F10X.ewp, settings and files
configuration STM32F103X8-WFC APP (ARM)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; WFC_APP
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../; ../../HwPlatform/STM32F10X/; ../../HwPlatform/STM32F10X/Core; ../../HwPlatform/STM32F10X/FirmwareLibrary; ../../HwPlatform/STM32F10X/HwDrivers; ../../HwPlatform/STM32F10X/Startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GCP-STM32F10X.bin
  ILINK.IlinkOutputFile: GCP-STM32F10X.out
  ILINK.IlinkIcfFile: settings\GCP-STM32F103X8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F103X8-MD APP (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; MD_APP
configuration STM32F103X8-LC APP (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; LC_APP
configuration STM32F103X8-BS08S (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; BS08S_APP
configuration STM32F103X8-BS08M (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; BS08M_APP
configuration STM32F103XC-WB01 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; WB01_APP
  OBJCOPY.OOCOutputFile: GCP-STM32F10X.hex
  ILINK.IlinkIcfFile: settings\GCP-STM32F103XB.icf
configuration STM32F103X8-BS05M (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; BS05M_APP
configuration STM32F103X8-BS05S (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3; STM32F10X; STM32F10X_HD; USE_STDPERIPH_DRIVER; BS05S_APP
  group Algorithm/CRC
    ../../Algorithm/CRC/: CRC.h CRC16.c CRC8.c
  group Algorithm/Json
    ../../Algorithm/Json/: cJSON.c cJSON.h
  group Algorithm/List
    ../../Algorithm/List/: List.h
  group Algorithm/RingBuff
    ../../Algorithm/RingBuff/: RingBuff.c RingBuff.h
  group Application
    ../../Application/: Application.h
  group Application/BS05M
    ../../Application/BS05M/: BS05M_AppVersion.h BS05M_ComMan.c BS05M_ComMan.h BS05M_HardwareDef.h BS05M_HwCtrl.c BS05M_HwCtrl.h BS05M_IOTable.c BS05M_IOTable.h BS05M_MainProc.c BS05M_MainProc.h
  group Application/BS05S
    ../../Application/BS05S/: BS05S_AppVersion.h BS05S_HardwareDef.h BS05S_HwCtrl.c BS05S_HwCtrl.h BS05S_IOTable.c BS05S_IOTable.h BS05S_MainProc.c BS05S_MainProc.h
  group Application/BS08M
    ../../Application/BS08M/: BS08M_AppVersion.h BS08M_ComMan.c BS08M_ComMan.h BS08M_HardwareDef.h BS08M_HwCtrl.c BS08M_HwCtrl.h BS08M_IOTable.c BS08M_IOTable.h BS08M_MainProc.c BS08M_MainProc.h
  group Application/BS08S
    ../../Application/BS08S/: BS08S_AppVersion.h BS08S_HardwareDef.h BS08S_HwCtrl.c BS08S_HwCtrl.h BS08S_IOTable.c BS08S_IOTable.h BS08S_MainProc.c BS08S_MainProc.h
  group Application/LEDController
    ../../Application/LEDController/: LC_AppVersion.h LC_HardwareDef.h LC_HwCtrl.c LC_HwCtrl.h LC_IODef.c LC_IODef.h LC_LEDCtrl.c LC_LEDCtrl.h LC_MainProc.c LC_MainProc.h LC_RfCom.c LC_RfCom.h
  group Application/MotorDriver
    ../../Application/MotorDriver/: MD103_IODef.c MD103_IODef.h MD_ComMan.c MD_ComMan.h MD_HardwareDef.h MD_HwCtrl.c MD_HwCtrl.h MD_MainProc.c MD_MainProc.h MD_MotorCtrl.c MD_MotorCtrl.h
  group Application/WB01
    ../../Application/WB01/: WB01_AppVersion.h WB01_CmdUnpack.c WB01_CmdUnpack.h WB01_ComMan.c WB01_ComMan.h WB01_HardwareDef.h WB01_HwCtrl.c WB01_HwCtrl.h WB01_IOTable.c WB01_IOTable.h WB01_MainProc.c WB01_MainProc.h
  group Application/WIFIClock
    ../../Application/WIFIClock/: WFC103_IOTable.c WFC103_IOTable.h WFC_HardwareDef.h WFC_HwCtrl.c WFC_HwCtrl.h WFC_MainProc.c WFC_MainProc.h WFC_WifiClock.c WFC_WifiClock.h WFC_WifiCom.c WFC_WifiCom.h
  group DataType
    ../../DataType/: DataType.h
  group ExtPeripheral/Ammeter
    ../../ExtPeripheral/Ammeter/: Ammeter_Spm91.c Ammeter_Spm91.h
  group ExtPeripheral/DAC
    ../../ExtPeripheral/DAC/: TLC5615.c TLC5615.h TLC5615_APP.c TLC5615_APP.h
  group ExtPeripheral/Eeprom
    ../../ExtPeripheral/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group ExtPeripheral/LCD
    ../../ExtPeripheral/LCD/: LCD.c LCD.h LCD1602.c LCD1602.h
  group ExtPeripheral/LogicIC
    ../../ExtPeripheral/LogicIC/: HC595.c HC595.h LogicIC.c LogicIC.h
  group ExtPeripheral/NixieTube
    ../../ExtPeripheral/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group ExtPeripheral/RF
    ../../ExtPeripheral/RF/: NRF24L01.c NRF24L01.h NRF24L01_RegDef.h RF.c RF.h
  group ExtPeripheral/TempSensor
    ../../ExtPeripheral/TempSensor/: Ds18b20.c Ds18b20.h TempSensor.c TempSensor.h
  group ExtPeripheral/WIFI
    ../../ExtPeripheral/WIFI/: ESP82XX.c ESP82XX.h
  group HAL
    ../../HAL/: Demo.c Demo.h HAL_ADC.c HAL_ADC.h HAL_Can.c HAL_Can.h HAL_Config.h HAL_Delay.c HAL_Delay.h HAL_Exti.c HAL_Exti.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Pwm.c HAL_Pwm.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysTick.c HAL_SysTick.h HAL_TimeCapture.c HAL_TimeCapture.h HAL_TimeReckon.c HAL_TimeReckon.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h
  group HwPlatform/STM32F10X/Core
    ../../HwPlatform/STM32F10X/Core/: chip.h core_cm3.c ring_buffer.c ring_buffer.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group HwPlatform/STM32F10X/FirmwareLibrary
    ../../HwPlatform/STM32F10X/FirmwareLibrary/: misc.c misc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h vssver2.scc
  group HwPlatform/STM32F10X/HwDrivers
    ../../HwPlatform/STM32F10X/HwDrivers/: HW_Adc.c HW_Adc.h HW_Can.c HW_Can.h HW_Exti.c HW_Exti.h HW_Flash.c HW_Flash.h HW_Gpio.c HW_Gpio.h HW_IRQHandler.c HW_IRQHandler.h HW_Spi.c HW_Spi.h HW_SysCtrl.c HW_SysCtrl.h HW_SysTick.c HW_SysTick.h HW_TimeComm.c HW_TimeComm.h HW_TimeDelay.c HW_TimeDelay.h HW_TimeInput.c HW_TimeInput.h HW_TimeOutput.c HW_TimeOutput.h HW_TimeReckon.c HW_TimeReckon.h HW_Uart.c HW_Uart.h HW_Watchdog.c HW_WatchDog.h
  group HwPlatform/STM32F10X/Startup
    ../../HwPlatform/STM32F10X/Startup/: iar_startup_stm32f10x_hd.s
  group Main
    ../../Main/: Main.c
  group SysCtrl
    ../../SysCtrl/: SYS_CmuConfig.c SYS_CmuConfig.h SYS_CncConfig.c SYS_CncConfig.h SYS_Config.h SYS_Ctrl.c SYS_Ctrl.h SYS_Init.c SYS_Init.h SYS_MemoryDef.h SYS_ParmMan.c SYS_ParmMan.h SysConfig.h
  group SysCtrl/SysUpdate
    ../../SysCtrl/SysUpdate/: Bootloader.c Bootloader.h SysUpdate.c SysUpdate.h
  group SysPeripheral/ADC
    ../../SysPeripheral/ADC/: ADC.c ADC.h
  group SysPeripheral/CAN
    ../../SysPeripheral/CAN/: CAN.c CAN.h CanBuff.c CanBuff.h CanDataStructDef.h
  group SysPeripheral/CoreCtrl
    ../../SysPeripheral/CoreCtrl/: CoreCtrl.c CoreCtrl.h
  group SysPeripheral/EXTI
    ../../SysPeripheral/EXTI/: EXTI.c EXTI.h
  group SysPeripheral/FLASH
    ../../SysPeripheral/FLASH/: Flash.c Flash.h
  group SysPeripheral/GPIO
    ../../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/I2C
    ../../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/PWM
    ../../SysPeripheral/PWM/: PWM.c PWM.h
  group SysPeripheral/RTC
    ../../SysPeripheral/RTC/: RTC.c RTC.h
  group SysPeripheral/SPI
    ../../SysPeripheral/SPI/: SPI.c SPI.h
  group SysPeripheral/SysTimer
    ../../SysPeripheral/SysTimer/: SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../../SysPeripheral/UART/: UART.c UART.h
  group SysPeripheral/WWDT
    ../../SysPeripheral/WWDT/: Watchdog.c Watchdog.h
  group Version
    ../../Version/: GCPVersion.h Version.h
