# IAR project GCP-STM32F0XX.ewp, settings and files
configuration STM32F030X4-BMC APP (ARM)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F0XX; BMC_APP
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../; ../../HwPlatform/STM32F0XX/; ../../HwPlatform/STM32F0XX/Core; ../../HwPlatform/STM32F0XX/FirmwareLibrary; ../../HwPlatform/STM32F0XX/HwDrivers; ../../HwPlatform/STM32F0XX/Startup
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GCP-STM32F0XX.bin
  ILINK.IlinkOutputFile: GCP-STM32F0XX.out
  ILINK.IlinkIcfFile: settings\GCP-STM32F0XX.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F030X4-IRB APP (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F0XX; IRB_APP
  group Algorithm/CRC
    ../../Algorithm/CRC/: CRC.h CRC16.c CRC8.c
  group Algorithm/Json
    ../../Algorithm/Json/: cJSON.c cJSON.h
  group Algorithm/RingBuff
    ../../Algorithm/RingBuff/: RingBuff.c RingBuff.h
  group Application
    ../../Application/: Application.h
  group Application/BLEMotorCtrl
    ../../Application/BLEMotorCtrl/: BMC030_IODef.c BMC030_IODef.h BMC_ComMan.c BMC_ComMan.h BMC_HardwareDef.h BMC_HwCtrl.c BMC_HwCtrl.h BMC_MainProc.c BMC_MainProc.h BMC_MotorCtrl.c BMC_MotorCtrl.h
  group Application/IRDoorBell
    ../../Application/IRDoorBell/: IRB030_IODef.c IRB030_IODef.h IRB_HardwareDef.h IRB_HwCtrl.c IRB_HwCtrl.h IRB_LEDCtrl.c IRB_LEDCtrl.h IRB_MainProc.c IRB_MainProc.h
  group DataType
    ../../DataType/: DataType.h
  group ExtPeripheral/Ammeter
    ../../ExtPeripheral/Ammeter/: Ammeter_Spm91.c Ammeter_Spm91.h
  group ExtPeripheral/Eeprom
    ../../ExtPeripheral/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group ExtPeripheral/LCD
    ../../ExtPeripheral/LCD/: LCD.c LCD.h LCD1602.c LCD1602.h
  group ExtPeripheral/NixieTube
    ../../ExtPeripheral/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group ExtPeripheral/RF
    ../../ExtPeripheral/RF/: NRF24L01.c NRF24L01.h NRF24L01_RegDef.h RF.c RF.h
  group ExtPeripheral/TempSensor
    ../../ExtPeripheral/TempSensor/: Ds18b20.c Ds18b20.h TempSensor.c TempSensor.h
  group ExtPeripheral/WIFI
    ../../ExtPeripheral/WIFI/: ESP82XX.c ESP82XX.h
  group HAL
    ../../HAL/: Demo.c Demo.h HAL_ADC.c HAL_ADC.h HAL_Can.c HAL_Can.h HAL_Config.h HAL_Delay.c HAL_Delay.h HAL_Exti.c HAL_Exti.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Pwm.c HAL_Pwm.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysTick.c HAL_SysTick.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h
  group HwPlatform/STM32F0XX/Core
    ../../HwPlatform/STM32F0XX/Core/: chip.h core_cm0.h core_cmFunc.h core_cmInstr.h ring_buffer.c ring_buffer.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group HwPlatform/STM32F0XX/HwDrivers
    ../../HwPlatform/STM32F0XX/HwDrivers/: HW_Adc.c HW_Adc.h HW_Can.c HW_Can.h HW_Exti.c HW_Exti.h HW_Flash.c HW_Flash.h HW_Gpio.c HW_Gpio.h HW_IRQHandler.c HW_IRQHandler.h HW_Spi.c HW_Spi.h HW_SysCtrl.c HW_SysCtrl.h HW_SysInit.c HW_SysInit.h HW_SysTick.c HW_SysTick.h HW_TimeComm.c HW_TimeComm.h HW_TimeDelay.c HW_TimeDelay.h HW_TimeInput.c HW_TimeInput.h HW_TimeOutput.c HW_TimeOutput.h HW_Uart.c HW_Uart.h HW_Watchdog.c HW_Watchdog.h
  group HwPlatform/STM32F0XX/Startup
    ../../HwPlatform/STM32F0XX/Startup/: startup_stm32f0xx.s
  group Main
    ../../Main/: Main.c
  group SysCtrl
    ../../SysCtrl/: SYS_CmuConfig.c SYS_CmuConfig.h SYS_CncConfig.c SYS_CncConfig.h SYS_Ctrl.c SYS_Ctrl.h SYS_Init.c SYS_Init.h SYS_MemoryDef.h SYS_ParmMan.c SYS_ParmMan.h SysConfig.h
  group SysCtrl/SysUpdate
    ../../SysCtrl/SysUpdate/: Bootloader.c Bootloader.h SysUpdate.c SysUpdate.h
  group SysPeripheral/CAN
    ../../SysPeripheral/CAN/: CAN.c CAN.h CanBuff.c CanBuff.h CanDataStructDef.h
  group SysPeripheral/CoreCtrl
    ../../SysPeripheral/CoreCtrl/: CoreCtrl.c CoreCtrl.h
  group SysPeripheral/EXTI
    ../../SysPeripheral/EXTI/: EXTI.c EXTI.h
  group SysPeripheral/FLASH
    ../../SysPeripheral/FLASH/: Flash.c Flash.h
  group SysPeripheral/GPIO
    ../../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/I2C
    ../../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/PWM
    ../../SysPeripheral/PWM/: PWM.c PWM.h
  group SysPeripheral/RTC
    ../../SysPeripheral/RTC/: RTC.c RTC.h
  group SysPeripheral/SPI
    ../../SysPeripheral/SPI/: SPI.c SPI.h
  group SysPeripheral/SysTimer
    ../../SysPeripheral/SysTimer/: SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../../SysPeripheral/UART/: UART.c UART.h
  group SysPeripheral/WWDT
    ../../SysPeripheral/WWDT/: Watchdog.c Watchdog.h
  group Version
    ../../Version/: GCPVersion.h Version.h
