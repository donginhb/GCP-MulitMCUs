# IAR project GCP-LPC17XX_Booloader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3; LPC17XX; BOOTLOADER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../; ../../HwPlatform/LPC17XX/; ../../HwPlatform/LPC17XX/Core; ../../HwPlatform/LPC17XX/FirmwareLibrary; ../../HwPlatform/LPC17XX/HwDrivers; ../../HwPlatform/LPC17XX/Startup
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GCP-LPC17XX_Booloader.bin
  ILINK.IlinkOutputFile: GCP-LPC17XX_Booloader.out
  ILINK.IlinkIcfFile: settings\GCP-LPC17XX_Booloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Algorithm/CRC
    ../../Algorithm/CRC/: CRC.h CRC16.c CRC8.c
  group Algorithm/RingBuff
    ../../Algorithm/RingBuff/: RingBuff.c RingBuff.h
  group Application
    ../../Application/: Application.h
  group Application/Bootloader
    ../../Application/Bootloader/: BT_HardwareDef.h BT_MainProc.c BT_MainProc.h VM_IOInit.c VM_IOInit.h
  group CMU
    ../../CMU/Simplify/: AbstractionLayer.c AbstractionLayer.h CMU_CanInterface.c CMU_CanInterface.h CMU_CmdProcess.c CMU_CmdProcess.h CMU_DataStructDef.h CMU_ErrorMana.c CMU_ErrorMana.h CMU_Init.c CMU_Init.h CMU_Interface.h CMU_UartInterface.c CMU_UartInterface.h CMU_Unpack.c CMU_Unpack.h
  group DataType
    ../../DataType/: DataType.h
  group HAL
    ../../HAL/: Demo.c Demo.h HAL_ADC.c HAL_ADC.h HAL_Can.c HAL_Can.h HAL_Config.h HAL_Delay.c HAL_Delay.h HAL_Exti.c HAL_Exti.h HAL_Flash.c HAL_Flash.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Pwm.c HAL_Pwm.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysTick.c HAL_SysTick.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h
  group HwPlatform/LPC17XX/Core
    ../../HwPlatform/LPC17XX/Core/: cmsis_175x_6x.h core_cm3.h error.h hw_types.h lpc_types.h sys_config.h
  group HwPlatform/LPC17XX/FirmwareLibrary
    ../../HwPlatform/LPC17XX/FirmwareLibrary/: adc_17xx_40xx.c adc_17xx_40xx.h can_17xx_40xx.c can_17xx_40xx.h chip.h chip_17xx_40xx.c chip_lpc175x_6x.h chip_lpc177x_8x.h clock_17xx_40xx.c clock_17xx_40xx.h cmp_17xx_40xx.c cmp_17xx_40xx.h cmsis.h crc_17xx_40xx.c crc_17xx_40xx.h dac_17xx_40xx.c dac_17xx_40xx.h eeprom_17xx_40xx.c eeprom_17xx_40xx.h emc_17xx_40xx.c emc_17xx_40xx.h enet_17xx_40xx.c enet_17xx_40xx.h fmc_17xx_40xx.h fpu_init.c fpu_init.h gpdma_17xx_40xx.c gpdma_17xx_40xx.h gpio_17xx_40xx.c gpio_17xx_40xx.h gpioint_17xx_40xx.c gpioint_17xx_40xx.h i2c_17xx_40xx.c i2c_17xx_40xx.h i2s_17xx_40xx.c i2s_17xx_40xx.h iap.c iap.h iocon_17xx_40xx.c iocon_17xx_40xx.h lcd_17xx_40xx.c lcd_17xx_40xx.h mcpwm_17xx_40xx.h pmu_17xx_40xx.c pmu_17xx_40xx.h pwm_17xx_40xx.c pwm_17xx_40xx.h qei_17xx_40xx.h ring_buffer.c ring_buffer.h ritimer_17xx_40xx.c ritimer_17xx_40xx.h romapi_17xx_40xx.h rtc_17xx_40xx.c rtc_17xx_40xx.h sdc_17xx_40xx.c sdc_17xx_40xx.h sdmmc_17xx_40xx.c sdmmc_17xx_40xx.h spi_17xx_40xx.c spi_17xx_40xx.h spifi_17xx_40xx.h ssp_17xx_40xx.c ssp_17xx_40xx.h sysctl_17xx_40xx.c sysctl_17xx_40xx.h sysinit_17xx_40xx.c timer_17xx_40xx.c timer_17xx_40xx.h uart_17xx_40xx.c uart_17xx_40xx.h usb_17xx_40xx.h wwdt_17xx_40xx.c wwdt_17xx_40xx.h
  group HwPlatform/LPC17XX/HwDrivers
    ../../HwPlatform/LPC17XX/HwDrivers/: HW_Can.c HW_Can.h HW_Exti.c HW_Exti.h HW_Flash.c HW_Flash.h HW_Gpio.c HW_Gpio.h HW_IRQHandler.c HW_IRQHandler.h HW_Mcpwm.c HW_Mcpwm.h HW_Pwm.c HW_Pwm.h HW_Rit.c HW_Rit.h HW_SysCtrl.c HW_SysCtrl.h HW_SysTick.c HW_SysTick.h HW_Tim.c HW_Tim.h HW_Uart.c HW_Uart.h HW_Watchdog.c HW_Watchdog.h
  group HwPlatform/LPC17XX/Startup
    ../../HwPlatform/LPC17XX/Startup/: iar_startup_LPC17xx.s sysinit.c
  group Main
    ../../Main/: Main.c
  group SysCtrl
    ../../SysCtrl/: SYS_CmuConfig.c SYS_CmuConfig.h SYS_Ctrl.c SYS_Ctrl.h SYS_Init.c SYS_Init.h SYS_MemoryDef.h SYS_ParmMan.c SYS_ParmMan.h SysConfig.h
  group SysCtrl/SysUpdate
    ../../SysCtrl/SysUpdate/: Bootloader.c Bootloader.h SysUpdate.c SysUpdate.h
  group SysPeripheral/CAN
    ../../SysPeripheral/CAN/: Can.c Can.h CanBuff.c CanBuff.h CanDataStructDef.h
  group SysPeripheral/CoreCtrl
    ../../SysPeripheral/CoreCtrl/: CoreCtrl.c CoreCtrl.h
  group SysPeripheral/FLASH
    ../../SysPeripheral/FLASH/: Flash.c Flash.h
  group SysPeripheral/GPIO
    ../../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/IRQ
    ../../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/SysTimer
    ../../SysPeripheral/SysTimer/: SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../../SysPeripheral/UART/: ModBus.c ModBus.h UART.c UART.h
  group SysPeripheral/WWDT
    ../../SysPeripheral/WWDT/: Watchdog.c Watchdog.h
  group Version
    ../../Version/: BootVersion.h GCPVersion.h Version.h
